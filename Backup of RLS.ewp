# IAR project Backup of RLS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZN64xxx2 NXP KEAZN64xxx2
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: Include; Sources\config_parameter; Sources\driver\clock; Sources\driver\adc; Sources\driver\eeprom; Sources\driver\ftm; Sources\driver\gpio; Sources\driver\pmc; Sources\driver\rtc; Sources\driver\SPI; Sources\LIN_app; Sources\lin_cfg; Sources\LIN_Stack\bsp\UART; Sources\LIN_Stack\coreapi; Sources\LIN_Stack\diagnostic; Sources\LIN_Stack\include; Sources\LIN_Stack\lowlevel; Sources\LIN_Stack\transport; Sources\RLS_app; Sources\driver\watchdog
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RLS.S19
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: Include; Sources\config_parameter; Sources\driver\adc; Sources\driver\clock; Sources\driver\eeprom; Sources\driver\ftm; Sources\driver\gpio; Sources\driver\pmc; Sources\driver\rtc; Sources\driver\SPI; Sources\LIN_app; Sources\lin_cfg; Sources\RLS_app; Sources\LIN_Stack\bsp\UART; Sources\LIN_Stack\coreapi; Sources\LIN_Stack\diagnostic; Sources\LIN_Stack\include; Sources\LIN_Stack\lowlevel; Sources\LIN_Stack\transport
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: RLS.srec
  group c_startup_kea64zn
    Startup/: cstartup_M_KEAZN64.s low_level_init.c
  group include
    Include/: derivative.h typedefs.h
  group Source
    Sources/: main.c
  group Source/config_parameter
    Sources/config_parameter/: config_parameter.c config_parameter.h
  group Source/driver/adc
    Sources/driver/adc/: adc.c adc.h
  group Source/driver/clock
    Sources/driver/clock/: clock.c clock.h
  group Source/driver/eeprom
    Sources/driver/eeprom/: eeprom.c eeprom.h
  group Source/driver/ftm
    Sources/driver/ftm/: ftm.c ftm.h
  group Source/driver/gpio
    Sources/driver/gpio/: gpio.c gpio.h
  group Source/driver/pmc
    Sources/driver/pmc/: pmc.c pmc.h
  group Source/driver/rtc
    Sources/driver/rtc/: rtc.c rtc.h
  group Source/driver/spi
    Sources/driver/SPI/: spi.c spi.h
  group Source/lin_app
    Sources/LIN_app/: lin_app.c lin_app.h
  group Source/lin_cfg
    Sources/lin_cfg/: lin_cfg.c lin_cfg.h lin_hw_cfg.h
  group Source/lin_stack/bsp
    Sources/LIN_Stack/bsp/UART/: lin_isr.c lin_lld_timesrv.c lin_lld_timesrv.h lin_lld_uart.c lin_lld_uart.h lin_reg.h
  group Source/lin_stack/coreapi
    Sources/LIN_Stack/coreapi/: lin_common_api.c lin_common_proto.c lin_j2602_api.c lin_j2602_proto.c lin_lin21_api.c lin_lin21_proto.c
  group Source/lin_stack/diagnostic
    Sources/LIN_Stack/diagnostic/: lin_diagnostic_service.c
  group Source/lin_stack/include
    Sources/LIN_Stack/include/: lin_common_api.h lin_common_proto.h lin_commontl_api.h lin_commontl_proto.h lin_diagnostic_service.h lin_j2602_api.h lin_j2602_proto.h lin_j2602tl_api.h lin_lin21_api.h lin_lin21_proto.h lin_lin21tl_api.h
  group Source/lin_stack/lowlevel
    Sources/LIN_Stack/lowlevel/: lin.c lin.h
  group Source/lin_stack/transport
    Sources/LIN_Stack/transport/: lin_commontl_api.c lin_commontl_proto.c lin_j2602tl_api.c lin_lin21tl_api.c
  group Source/rls_app
    Sources/RLS_app/: rls_app.c rls_app.h
  group Source/watchdog
    Sources/driver/watchdog/: watchdog.c watchdog.h
